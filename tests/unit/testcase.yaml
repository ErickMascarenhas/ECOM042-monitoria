## tests/unit/testcase.yaml
```yaml
tests:
  app.led.unit:
    platform_allow:
      - native_sim
    tags:
      - led
      - unit
    harness: ztest
```
